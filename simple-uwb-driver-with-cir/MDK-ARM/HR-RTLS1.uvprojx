# Keil uVision project HR-RTLS1.uvprojx, settings and files
target HR-RTLS1 (6090000::V6.9::.\ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HR-RTLS1 +hex
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include;   ..\Src\application;   ..\Src\compiler;   ..\Src\decadriver;   ..\Src\e2prom;   ..\Src\kalmanfilter;   ..\Src\platform;   ..\Src\trilateration;   ..\Src\OLED;   ..\Src\imu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c dma.c i2c.c iwdg.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group DW_application
    ../Src/application/: dw_main.c instance_anchor.c instance_tag.c
  group DW_driver
    ../Src/decadriver/: deca_device.c deca_params_init.c
  group DW_platform
    ../Src/platform/: deca_mutex.c deca_range_tables.c deca_sleep.c deca_spi.c port.c
  group Kalmanfiter
    ../Src/kalmanfilter/: kalman.c
  group E2prom
    ../Src/e2prom/: e2prom.c
  group Trilateration
    ../Src/trilateration/: trilateration.c
  group OLED
    ../Src/OLED/: fonts.c ssd1306.c
  group imu
    ../Src/imu/: icm42605.c
software components: CMSIS:CORE 5.1.1
